options:
  parameters:
    generate_options: qt_gui
    id: brennenstuhl_rx
    output_language: python
    title: Brennenstuhl RX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.53e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: threshold_high
  id: variable_qtgui_range
  parameters:
    label: Threshold High
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0.035'
  states: {}
- name: threshold_low
  id: variable_qtgui_range
  parameters:
    label: Threshold Low
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0.02'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/brennenstuhl/remote_a_on.threshold.signal
    type: float
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/gnuradio/buffer.signal
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/brennenstuhl/remote_abcd_onoff.signal
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '100'
    scale: 1/20
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold_high
    init: '0'
    low: threshold_low
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: brennenstuhl_demodulator_0
  id: brennenstuhl_demodulator
  parameters:
    debug: 'True'
    fixed_symbol_len: '262'
    max_symbol_len: '100000'
    min_symbol_len: '0'
  states: {}
- name: brennenstuhl_parser_0
  id: brennenstuhl_parser
  parameters:
    debug: 'False'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_char_0, '0', brennenstuhl_demodulator_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [brennenstuhl_demodulator_0, brennenstuhl_demod, blocks_message_debug_0, store]
- [brennenstuhl_demodulator_0, brennenstuhl_demod, brennenstuhl_parser_0, packet]
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_2, '0']

metadata:
  file_format: 1
