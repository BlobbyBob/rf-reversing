options:
  parameters:
    generate_options: qt_gui
    id: brennenstuhl_tx
    output_language: python
    title: Brennenstuhl Tx
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.53e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 45e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/gnuradio/modulated.signal
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/virt.signal
    type: complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: brennenstuhl_modulator_0
  id: brennenstuhl_modulator
  parameters:
    ifs_length: '189000'
    symbol_length: '26200'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    color1: '"black"'
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HANN
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_1, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_1, '0', blocks_float_to_complex_1, '1']
- [brennenstuhl_modulator_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
