options:
  parameters:
    generate_options: qt_gui
    id: thermometer_rx
    output_language: python
    title: Thermometer Receiver
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.95e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.015'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/thermometer/only_sensor.signal
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/thermometer/water.signal
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/thermometer/first_test.mono.signal
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/thermometer/first_test.threshold.signal
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/blobbybob/Documents/rf_hacking/thermometer/water.signal
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '100'
    scale: 1/20
    type: float
  states: {state: bypassed}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.015'
    init: '0'
    low: '0.015'
  states: {state: disabled}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.015'
    init: '0'
    low: '0.015'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: globaltronics_decoder_0
  id: globaltronics_decoder
  parameters: {}
  states: {}
- name: globaltronics_demodulator_0
  id: globaltronics_demodulator
  parameters:
    fixed_symlen_long: '850'
    fixed_symlen_short: '450'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '256'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_file_sink_1_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_char_0, '0', globaltronics_demodulator_0, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_1_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [globaltronics_demodulator_0, globaltronics_demod, globaltronics_decoder_0, globaltronics_decode]
- [osmosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
