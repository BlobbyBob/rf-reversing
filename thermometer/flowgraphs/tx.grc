options:
  parameters:
    generate_options: qt_gui
    id: thermometer_tx
    output_language: python
    title: Globaltronics TX
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.95e6
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '-100e3'
    step: 1e3
    stop: 100e3
    value: '-20e3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: globaltronics_modulator_0
  id: globaltronics_modulator
  parameters:
    repetitions: '7'
    sample_rate: samp_rate
  states: {}
- name: note_0
  id: note
  parameters:
    note: This is a sample flowgraph how a transmission flowgraph could look
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_uchar_to_float_0, '0', blocks_float_to_complex_0, '0']
- [globaltronics_modulator_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
